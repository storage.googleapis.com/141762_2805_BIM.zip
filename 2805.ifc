Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-24T22:52:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 24 22:52:58 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{FFB49BF0-9FAE-472B-90E1-E113A4C317C1}\ifc * Database version: 5507 * Database creation date: Fri Aug 24 22:52:58 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 24 22:52:58 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 24 22:52:58 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 2805 Washbasin faucet, 2805:2805 Washbasin faucet:332863
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 210 mm; NominalHeight: 174.5 mm; NominalWidth: 50 mm; Projection: 160 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 2805; ConvergoRefNr: 0087-1809-0110-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 22/08/2018
Type - Green Building Properties(Type) - EAN Number: 6414150058615; EN Standard: EN 817; ETA-Danmark: VA 1.42/17872; LVI Number: 6118730 6118730; Noise Class: I (ISO 3822); RSK Number: 8347846; Sintef Certificate: Sintef Nr. 1322; STF Certificate: VTT-RTH-04951-08; VVS Number: 701961104
Type - Identity Data(Type) - Class: Single lever; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;POL;RUS;SWE;UKR; Model: 2805 Washbasin faucet; Name_en: 2805 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2805; Product Datasheet: https://www.oras.com/datasheet/2805/en; Product Family: Oras Cubista; Product URL: https://www.oras.com/en/products/oras/product/2805; Type Name: 2805 Washbasin faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: Ø10 mm; Extensions: Rapid pop-up waste; Flow Rate At 300kPa: 0.00706293 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/109791_PDM_943013_F_(943013-01-16).pdf; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 01ls: 70000 Pa; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP2810/; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2805; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2805; Name: 2805 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x210x175 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2805; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2805 Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0569695 m2; Volume: 0.00183696 m3
Identity Data - Mark: 11
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 2805: 2805 Washbasin faucet; Family and Type: 2805: 2805 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2805: 2805 Washbasin faucet; Type Id: 2805: 2805 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
